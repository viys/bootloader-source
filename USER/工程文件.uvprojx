# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\工程文件.bin  ..\OBJ\工程文件.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: ..\USER;..\CMSIS\Include;..\HW\Include;..\LIB\Include
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group CMSIS
    ../CMSIS/Source/: system_gd32f10x.c startup_gd32f10x_md.s
  group HW
    ../HW/Source/: gd32f10x_it.c usart.c delay.c iic.c m24c02.c spi.c w25q64.c fmc.c 4g.c mqtt.c
  group LIB
    ../LIB/Source/: gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_gpio.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_spi.c gd32f10x_fmc.c gd32f10x_exti.c
